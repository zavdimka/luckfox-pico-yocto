# Ensure config.rpath is available for native builds
DEPENDS:append:class-native = " gettext-native"
DEPENDS:append:class-nativesdk = " gettext-native"
